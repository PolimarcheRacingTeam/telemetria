# Keil uVision project test1.uvprojx, settings and files
target test1 (ARM-ADS)
  device: STM32F746ZGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: test1
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx
  c misc: --C99
  c include: ../Inc;../Middlewares/Third_Party/LwIP/src/include;../Middlewares/Third_Party/LwIP/system;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FatFs/src/drivers;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../Middlewares/Third_Party/FatFs/src;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/LwIP/src/include/lwip;../Middlewares/Third_Party/LwIP/src/include/lwip/apps;../Middlewares/Third_Party/LwIP/src/include/lwip/priv;../Middlewares/Third_Party/LwIP/src/include/lwip/prot;../Middlewares/Third_Party/LwIP/src/include/netif;../Middlewares/Third_Party/LwIP/src/include/netif/ppp;../Middlewares/Third_Party/LwIP/src/include/netif/ppp/polarssl;../Middlewares/Third_Party/LwIP/src/include/posix;../Middlewares/Third_Party/LwIP/src/include/posix/sys;../Middlewares/Third_Party/LwIP/system/arch;../Drivers/CMSIS/Include
  asm include: ..\Inc;../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: event_groups.c queue.c croutine.c timers.c list.c tasks.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_flash.c stm32f7xx_hal_eth.c stm32f7xx_hal_cortex.c stm32f7xx_hal.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_gpio.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_can.c stm32f7xx_hal_adc.c stm32f7xx_hal_sd.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_i2c.c stm32f7xx_hal_uart.c stm32f7xx_hal_rcc.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
    ../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c diskio.c ff.c
    ../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Application/User
    ../Src/: adc.c i2c.c sdmmc.c ethernetif.c fatfs.c gpio.c freertos.c lwip.c usart.c stm32f7xx_it.c stm32f7xx_hal_msp.c bsp_driver_sd.c can.c main.c stm32f7xx_hal_timebase_TIM.c
    ../Inc/: adcSampling.h
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: ppp.c eap.c chap-md5.c pppcrypt.c chap_ms.c magic.c ccp.c eui64.c pppos.c multilink.c pppol2tp.c upap.c vj.c ipcp.c ecp.c pppapi.c pppoe.c demand.c ipv6cp.c chap-new.c lcp.c fsm.c auth.c mppe.c utils.c
    ../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c lowpan6.c slipif.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: icmp.c autoip.c ip4_frag.c ip4.c etharp.c dhcp.c igmp.c ip4_addr.c
    ../Middlewares/Third_Party/LwIP/src/core/: dns.c udp.c tcp_out.c sys.c stats.c tcp_in.c timeouts.c tcp.c raw.c def.c pbuf.c ip.c memp.c inet_chksum.c mem.c init.c netif.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: ip6.c ip6_addr.c mld6.c ethip6.c nd6.c dhcp6.c icmp6.c ip6_frag.c inet6.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/polarssl/: des.c md5.c arc4.c md4.c sha1.c
    ../Middlewares/Third_Party/LwIP/src/api/: tcpip.c netdb.c err.c api_msg.c netifapi.c api_lib.c sockets.c netbuf.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
software components: CMSIS:CORE 4.1.0
