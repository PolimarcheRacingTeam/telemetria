<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\prova_adc_potenziometro.ewp</path>
  </project>
  <batchBuild />
</workspace>
